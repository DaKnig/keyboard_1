## config/boards/shields/keyboard_1_left/Kconfig.defconfig
```kconfig
if SHIELD_KEYBOARD_1

config ZMK_KEYBOARD_NAME
    default keyboard_1_left

endif
```
